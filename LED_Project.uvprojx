# Keil uVision project LED_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\Source code\MCAL\GPIO;.\Source code\MCAL\GPT;.\Source code\MCAL\Inc;.\Source code\Config;.\Source code\Common;.\Source code\Appl\LED;.\Source code\Appl\SWITCH
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ./Source code/MCAL/GPT/: GPT.c
    ./Source code/MCAL/GPIO/: GPIO.c
    ./Source code/MCAL/Inc/: IntCtrl.c
  group Appl
    ./Source code/Appl/: Project_LED.c
    ./Source code/Appl/SWITCH/: Switch.c
    ./Source code/Appl/LED/: LED_PROGRAM.c
  group Config
    ./Source code/Config/: GPIO_Lcfg.c GPT_Lcfg.c IntCtrl_Lcfg.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, CMSIS:NN Lib 4.0.0, Device:Startup 1.0.1
