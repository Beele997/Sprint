# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\ARM_CortexM4\Source code\Appl\LED;..\ARM_CortexM4\Source code\Appl\SWITCH;..\ARM_CortexM4\Source code\Common;..\ARM_CortexM4\Source code\Config;..\ARM_CortexM4\Source code\MCAL\GPIO;..\ARM_CortexM4\Source code\MCAL\GPT;..\ARM_CortexM4\Source code\MCAL\Inc;..\ARM_CortexM4\Source code\HAL\SWITCH;..\ARM_CortexM4\Source code\HAL\LED
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Config
    ../ARM_CortexM4/Source code/Config/: GPIO_Lcfg.c GPT_Lcfg.c IntCtrl_Lcfg.c
  group Mcal
    ../ARM_CortexM4/Source code/MCAL/GPIO/: GPIO.c
    ../ARM_CortexM4/Source code/MCAL/GPT/: GPT.c
    ../ARM_CortexM4/Source code/MCAL/Inc/: IntCtrl.c
  group Appl
    ../ARM_CortexM4/Source code/Appl/: Project_LED.c
    ../ARM_CortexM4/Source code/HAL/LED/: LED_PROGRAM.c
    ../ARM_CortexM4/Source code/HAL/SWITCH/: Switch.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
